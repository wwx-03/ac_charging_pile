# Keil uVision project HSEVB_AC7KCAR01_V2.0_SV1.0.0.uvprojx, settings and files
target HSEVB_AC7KCAR01_V2.0_SV1.0.0 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: HSEVB_AC7KCAR01_V2.0_SV1.0.0 +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../BSP/Inc;../SEGGER;../user_drivers/LAR01;../user_drivers/TJC_LCD;../user_drivers/WS2812;../user_drivers/BL0940;../app/inc;../service/YKC;../user_drivers/FLASH;../user_drivers/RC522;../user_drivers/Time;..\user_drivers\tpc_lcd;..\user_drivers\WT6040;..\board\inc
  asm include: ../Core/Inc;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8004000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c dma.c iwdg.c rtc.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group SEGGER
    ../SEGGER/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group service
    ../service/YKC/: cloud_charge_dispatch.c cloud_charge_protocol.c cloud_charge_protocol_ex_hs.c cloud_charge_dispatch_ex_hs.c
  group bsp
    ../BSP/Src/: bsp_uart.c bsp_lar01.c bsp_bl0940.c bsp_tjc_lcd.c bsp_strip_led.c bsp_flash.c bsp_adc.c bsp_rc522.c bsp_time.c bsp_pvd.c bsp_tpc_lcd.c bsp_wt6040.c
  group user_drivers
    ../user_drivers/TJC_LCD/: TJC_LCD.c
    ../user_drivers/LAR01/: lar01.c
    ../user_drivers/WS2812/: ws2812.c
    ../user_drivers/BL0940/: bl0940.c
    ../user_drivers/FLASH/: flash.c
    ../user_drivers/RC522/: rc522.c
    ../user_drivers/Time/: tm.c
    ../user_drivers/tpc_lcd/: tpc_lcd.c
    ../user_drivers/WT6040/: wt6040.c
  group app_interface
    ../app/inc/: charge.h display.h led.h meter.h network.h order.h protocol.h rfid.h switch.h button.h gun.h
  group app
    ../app/src/: application.c display_tjc_lcd.c display_tpc_lcd.c led_ws2812.c meter_bl0940.c network_lar01.c device.c button.c charge.c rfid_rc522.c switch_relay.c protocol_clound_charge.c settings.c order.c gun.c app_pwm.c pvd.c beep.c audio.c
software components: CMSIS:CORE 5.4.0
